RDEPENDS_packagegroup-core-buildessential_remove = "gcc-symlinks cpp-symlinks g++-symlinks"
